PACKAGECONFIG_remove_zynqmp = "egl gles"

PROVIDES_remove_zynqmp = "virtual/libgles1 virtual/libgles2 virtual/egl"
