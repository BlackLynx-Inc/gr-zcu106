RDEPENDS_${PN}_remove_zynqmp-generic = "mali-modules"
